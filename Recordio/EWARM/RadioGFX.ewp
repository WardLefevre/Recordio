# IAR project RadioGFX.ewp, settings and files
configuration RadioGFX (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx; USE_BPP=16
  ICCARM.CCIncludePath2: ../FATFS/Target; ../FATFS/App; ../Core/Inc; ../TouchGFX/target; ../USB_HOST/App; ../USB_HOST/Target; ../TouchGFX/generated/fonts/include; ../TouchGFX/generated/texts/include; ../TouchGFX/generated/images/include; ../TouchGFX/generated/gui_generated/include; ../TouchGFX/gui/include; ..\Middlewares\ST\TouchGFX\touchgfx\framework\include; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1; ../Middlewares/ST/STM32_USB_Host_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Inc; ../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../Drivers/CMSIS/Include; C:\Users\Ward\STM32Cube\Repository\STM32Cube_FW_F7_V1.15.0\Drivers\BSP\STM32746G-Discovery
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: RadioGFX.hex
  ILINK.IlinkOutputFile: RadioGFX.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f746xx.s
  group Application/User/Core
    ../Core/Src/: main.cpp freertos.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c fatfs_platform.c
  group Application/User/TouchGFX/generated/fonts
    ../TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp Font_calibri_20_4bpp.cpp Font_calibri_30_4bpp.cpp Font_calibri_40_4bpp.cpp Font_verdana_10_4bpp.cpp FontGetters.cpp Kerning_calibri_20_4bpp.cpp Kerning_calibri_30_4bpp.cpp Kerning_calibri_40_4bpp.cpp Kerning_verdana_10_4bpp.cpp Table_calibri_20_4bpp.cpp Table_calibri_30_4bpp.cpp Table_calibri_40_4bpp.cpp Table_verdana_10_4bpp.cpp
  group Application/User/TouchGFX/generated/gui_generated/common
    ../TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/screen1_screen
    ../TouchGFX/generated/gui_generated/src/screen1_screen/: Screen1ViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/screen2_screen
    ../TouchGFX/generated/gui_generated/src/screen2_screen/: Screen2ViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/screensaver1_screen
    ../TouchGFX/generated/gui_generated/src/screensaver1_screen/: Screensaver1ViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/screensaver2_screen
    ../TouchGFX/generated/gui_generated/src/screensaver2_screen/: Screensaver2ViewBase.cpp
  group Application/User/TouchGFX/generated/images
    ../TouchGFX/generated/images/src/: background.cpp BitmapDatabase.cpp btn_round.cpp btn_round_pressed.cpp Down_arrow.cpp Down_arrow_pressed.cpp Go_back_Edit.cpp Go_next_Edit.cpp Home_Edit.cpp Pause_Edit.cpp Power_Edit.cpp Search_Edit.cpp Settings_Edit.cpp Up_arrow.cpp Up_arrow_pressed.cpp
  group Application/User/TouchGFX/generated/images/__designer
    ../TouchGFX/generated/images/src/__designer/: blue_slider_horizontal_medium_slider2_round_back.cpp dark_icons_go_back_32.cpp dark_icons_go_next_32.cpp dark_icons_home_48.cpp dark_icons_play_48.cpp dark_icons_power_48.cpp dark_icons_search_48.cpp dark_icons_settings_48.cpp dark_slider_horizontal_medium_indicators_slider2_round_nob.cpp
  group Application/User/TouchGFX/generated/texts
    ../TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/User/TouchGFX/gui/common
    ../TouchGFX/gui/src/common/: FrontendApplication.cpp
  group Application/User/TouchGFX/gui/model
    ../TouchGFX/gui/src/model/: Model.cpp
  group Application/User/TouchGFX/gui/screen1_screen
    ../TouchGFX/gui/src/screen1_screen/: Screen1Presenter.cpp Screen1View.cpp
  group Application/User/TouchGFX/gui/screen2_screen
    ../TouchGFX/gui/src/screen2_screen/: Screen2Presenter.cpp Screen2View.cpp
  group Application/User/TouchGFX/gui/screensaver1_screen
    ../TouchGFX/gui/src/screensaver1_screen/: Screensaver1Presenter.cpp Screensaver1View.cpp
  group Application/User/TouchGFX/gui/screensaver2_screen
    ../TouchGFX/gui/src/screensaver2_screen/: Screensaver2Presenter.cpp Screensaver2View.cpp
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: BoardConfiguration.cpp GPIO.cpp STM32F7DMA.cpp STM32F7HAL.cpp STM32F7TouchController.cpp STM32F7Instrumentation.cpp HW_Init.cpp
  group Application/User/USB_HOST/App
    ../USB_HOST/App/: usb_host.c
  group Application/User/USB_HOST/Target
    ../USB_HOST/Target/: usbh_conf.c usbh_platform.c
  group Drivers/BSP
    ../../../../STM32Cube/Repository/STM32Cube_FW_F7_V1.15.0/Drivers/BSP/Components/ft5336/: ft5336.c
    ../../../../STM32Cube/Repository/STM32Cube_FW_F7_V1.15.0/Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_qspi.c stm32746g_discovery_ts.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_dma2d.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_hcd.c stm32f7xx_ll_usb.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_sd.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_exti.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group Middlewares/TouchGFX
    ../Middlewares/ST/TouchGFX/touchgfx/lib/core/cortex_m7/IAR8.x/: touchgfx_core_release.a
    ../Middlewares/ST/TouchGFX/touchgfx/os/: OSWrappers.cpp
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Src/: usbh_cdc.c
